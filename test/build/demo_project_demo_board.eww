<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  
  
  
  
  <batchBuild>
    
    
  <batchDefinition><name>all</name><member><project>demo_project</project><configuration>debug</configuration></member><member><project>demo_project</project><configuration>release</configuration></member></batchDefinition><batchDefinition><name>debug</name><member><project>demo_project</project><configuration>debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>demo_project</project><configuration>release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/demo_project_demo_board.ewp</path></project></workspace>
