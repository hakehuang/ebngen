# Keil uVision project demo_project_demo_board.uvprojx, settings and files
target release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4.fp")
  output: motor_demo.out
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, TWR_K64F120M, EMPL_TARGET_KINETIS, MPU6050, EMPL, USE_DMP
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186 
--diag_suppress=66
  c include: ../../../../bsp/kinetis/platform/devices;../../../../bsp/kinetis/platform/devices/MK64F12/include;../../../../bsp/kinetis/platform/devices/MK64F12/startup;../../../../bsp/kinetis/boards/twrk64f120m;../../../../bsp/kinetis/common/sgtl5000;../../../../bsp/kinetis/common/phyksz8041;../../../../bsp/kinetis/platform/system/src/clock/MK64F12;../../../../utils/mdp/core/driver/eMPL;../../../../utils/mdp/core/driver/include;../../../../utils/mdp/core/mllite;../../../../utils/mdp/core/mpl;../../../../utils/mdp/core/eMPL-hal;../../../../bsp/kinetis/motor_app;../../../../bsp/kinetis/platform/drivers/inc;../../../../bsp/kinetis/platform/hal/inc;../../../../bsp/kinetis/rtos;../../../../bsp/kinetis/platform/osa/inc;../../../../bsp/kinetis/platform/CMSIS/Include;../../../../bsp/kinetis/platform/system/inc;../../../../bsp/kinetis/platform/utilities/inc;../../../../bsp/kinetis/platform/utilities/src;../../../../components/drivers/include/drivers;../../../../components/drivers/include;../../../../bsp/kinetis/driver_wrapper/inc;../../../../components/finsh;../../../../include
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../bsp/kinetis/platform/devices/MK64F12/linker/arm/MK64FN1M0xxx12_flash.scf
  link misc: ../../../../utils/mdp/core/mpl/arm/Keil/libmpllib_Keil_M4FP/libmpllib.lib 
../../../../lib/ksdk_platform_lib/MK64F12/KsdkPlatformLib/mdk/debug/libksdk_platform.lib 
--remove 
--predefine="-D__ram_vector_table__=1"
target debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: CPUTYPE("Cortex-M4.fp")
  output: motor_demo.out
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: as above
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: as above
  link misc: as above
