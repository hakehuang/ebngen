# IAR project hello_world_frdmk64f.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; TOOLCHAIN_IAR; FRDM_K64F120M; TARGET_K64F; __MBED__; DEVICE_STDIO_MESSAGES=1; _DLIB_FILE_DESCRIPTOR=1; __CORTEX_M4F; CPU_MK64FN1M0VMD12; DEBUG; TOOLCHAIN_IAR
  ICCARM.IExtraOptions: -e; --cpu=Cortex-M4; --fpu=vfpv4_sp_d16; -e; --cpu=Cortex-M4; --fpu=vfpv4_sp_d16
  ICCARM.CCIncludePath2: ../../../../hello_world; ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/TARGET_FRDM; ../../../..; ../../../../cmsis; ../../../../drivers; ../../../../events; ../../../../events/equeue; ../../../../rtos; ../../../../platform; ../../../../hal; ../../../../hal/hal; ../../../../hal/storage_abstraction; ../../../../rtos/rtx/TARGET_CORTEX_M; ../../../../rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7; ../../../../targets/TARGET_Freescale; ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/api; ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/device; ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/drivers; ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F; ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/sdk_drivers; ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/TARGET_FRDM; ../../../../cmsis; ../../../../drivers; ../../../../events; ../../../../events/equeue; ../../../../rtos; ../../../../hal; ../../../../hal/hal; ../../../../hal/storage_abstraction; ../../../../platfrom; ../../../../rtos/rtx/TARGET_CORTEX_M; ../../../../rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7; ../../../../targets/TARGET_Freescale; ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/api; ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/device; ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/drivers; ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F; ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/sdk_drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: --cpu Cortex-M4; --fpu=vfpv4_sp_d16
  OBJCOPY.OOCOutputFile: appgeneric.srec
  ILINK.IlinkOutputFile: K70_pit_drivers_test.out
  ILINK.IlinkConfigDefines: --skip_dynamic_initialization; --threaded_lib
  ILINK.IlinkIcfFile: ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/device/TOOLCHAIN_IAR/MK64FN1M0xxx12.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NDEBUG; TOOLCHAIN_IAR; FRDM_K64F120M; TARGET_K64F; __MBED__; DEVICE_STDIO_MESSAGES=1; _DLIB_FILE_DESCRIPTOR=1; __CORTEX_M4F; CPU_MK64FN1M0VMD12; TOOLCHAIN_IAR
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: twrk70f120m.out
  group mbed:portable
    ../../../../rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_IAR/: HAL_CM4.S SVC_Table.S
  group startup
    ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/device/TOOLCHAIN_IAR/: startup_MK64F12.S
  group hello_world
    ../../../../hello_world/: main.cpp
  group board
    ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/TARGET_FRDM/: PeripheralPins.c crc.c fsl_clock_config.c fsl_phy.c mbed_overrides.c PeripheralNames.h PinNames.h crc.h device.h fsl_clock_config.h fsl_phy.h
  group mbed
    ../../../../: mbed.h
  group rtos
    ../../../../rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.c rtos_idle.h RtosTimer.cpp Semaphore.cpp Semaphore.h Thread.cpp Thread.h
    ../../../../rtos/rtx/TARGET_CORTEX_M/: RTX_CM_lib.h RTX_Config.h cmsis_os.h rt_Event.h rt_HAL_CM.h rt_List.h rt_Mailbox.h rt_MemBox.h rt_Memory.h rt_Mutex.h rt_OsEventObserver.h rt_Robin.h rt_Semaphore.h rt_System.h rt_Task.h rt_Time.h rt_Timer.h rt_TypeDef.h HAL_CM.c RTX_Conf_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_OsEventObserver.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group cmsis
    ../../../../rtos/: arm_common_tables.h arm_const_structs.h arm_math.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h
  group hal
    ../../../../hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    ../../../../hal/hal/: emac_api.h
    ../../../../hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
  group mbed-drivers
    ../../../../drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h AnalogIn.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp RawSerial.cpp SPI.cpp SPISlave.cpp Serial.cpp SerialBase.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp
  group platform
    ../../../../platform/: CThunk.h CallChain.h Callback.h CircularBuffer.h FunctionPointer.h PlatformMutex.h SingletonPtr.h Transaction.h critical.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h platform.h rtc_time.h semihost_api.h toolchain.h wait_api.h mbed_assert.c mbed_board.c mbed_critical.c mbed_error.c mbed_interface.c mbed_mem_trace.c mbed_semihost_api.c mbed_wait_api_no_rtos.c CallChain.cpp mbed_alloc_wrappers.cpp mbed_rtc_time.cpp mbed_wait_api_rtos.cpp retarget.cpp
  group api
    ../../../../targets/TARGET_Freescale/: mbed_rtx.h
    ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/api/: PeripheralPins.h PortNames.h gpio_object.h objects.h analogin_api.c analogout_api.c gpio_api.c gpio_irq_api.c i2c_api.c lp_ticker.c pinmap.c port_api.c rtc_api.c sleep.c
  group clock
    ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/drivers/: fsl_clock.c fsl_clock.h
  group device
    ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/device/: MK64F12.h MK64F12_features.h cmsis.h cmsis_nvic.h fsl_device_registers.h system_MK64F12.h cmsis_nvic.c system_MK64F12.c
  group porting
    ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/device/: MK64F12.h MK64F12_features.h cmsis.h cmsis_nvic.h fsl_device_registers.h system_MK64F12.h
    ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/: peripheral_clock_defines.h pwmout_api.c serial_api.c spi_api.c storage_driver.c trng_api.c us_ticker.c
  group drivers
    ../../../../targets/TARGET_Freescale/TARGET_KSDK2_MCUS/sdk_drivers/: fsl_uart.h fsl_uart.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_pit.c fsl_pit.h fsl_enet.h fsl_enet.c fsl_common.c fsl_common.h fsl_flash.c fsl_flash.h
