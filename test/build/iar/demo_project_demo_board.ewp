# IAR project demo_project_demo_board.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; TWR_K64F120M
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../bsp/kinetis/platform/devices/MK64F12/startup; ../../../../bsp/kinetis/boards/frdmk64f; ../../../../bsp/kinetis/common/sgtl5000; ../../../../bsp/kinetis/common/phyksz8041; ../../../../bsp/kinetis/platform/system/src/clock/MK64F12; ../../../../bsp/kinetis/rt_app; ../../../../bsp/kinetis/platform/drivers/inc; ../../../../bsp/kinetis/platform/hal/inc; ../../../../bsp/kinetis/rtos; ../../../../bsp/kinetis/platform/osa/inc; ../../../../bsp/kinetis/platform/CMSIS/Include; ../../../../bsp/kinetis/platform/system/inc; ../../../../bsp/kinetis/platform/utilities/inc; ../../../../bsp/kinetis/platform/utilities/src; ../../../../components/drivers/include/drivers; ../../../../components/drivers/include; ../../../../bsp/kinetis/driver_wrapper/inc; ../../../../components/finsh; ../../../../include; ../../test; ../../test
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AExtraOptionsV2: -S
  OBJCOPY.OOCOutputFile: appgeneric.srec
  ILINK.IlinkOutputFile: rt_thread_demo.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../devices/MK64F12/iar/MK64FN1M0xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/MK64F12/KsdkPlatformLib/iar/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VMD12; TWR_K64F120M
  ICCARM.CCIncludePath2: ../../../../bsp/kinetis/platform/devices; ../../../../bsp/kinetis/platform/devices/MK64F12/include; ../../../../bsp/kinetis/platform/devices/MK64F12/startup; ../../../../bsp/kinetis/boards/frdmk64f; ../../../../bsp/kinetis/common/sgtl5000; ../../../../bsp/kinetis/common/phyksz8041; ../../../../bsp/kinetis/platform/system/src/clock/MK64F12; ../../../../bsp/kinetis/rt_app; ../../../../bsp/kinetis/platform/drivers/inc; ../../../../bsp/kinetis/platform/hal/inc; ../../../../bsp/kinetis/rtos; ../../../../bsp/kinetis/platform/osa/inc; ../../../../bsp/kinetis/platform/CMSIS/Include; ../../../../bsp/kinetis/platform/system/inc; ../../../../bsp/kinetis/platform/utilities/inc; ../../../../bsp/kinetis/platform/utilities/src; ../../../../components/drivers/include/drivers; ../../../../components/drivers/include; ../../../../bsp/kinetis/driver_wrapper/inc; ../../../../components/finsh; ../../../../include
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../../../bsp/kinetis/platform/devices/MK64F12/linker/iar/MK64FN1M0xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/MK64F12/KsdkPlatformLib/iar/release/libksdk_platform.a
  group src
    ../../: hello_world.c
  group include
    ../../: hello_world.h
