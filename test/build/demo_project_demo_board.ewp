# IAR project demo_project_demo_board.ewp, settings and files
  group 
    ../: hello_world.c
  group 
    ../: hello_world.h
